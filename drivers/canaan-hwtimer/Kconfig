## drivers/canaan-hwtimer/Kconfig
```kconfig
menu "canaan-hwtimer"


config CANAAN_HWTIMER
	bool "canaan hwtimer driver"
	default ARCH_CANAAN

endmenu
```
